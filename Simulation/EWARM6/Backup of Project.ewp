# IAR project Backup of Project.ewp, settings and files
configuration STM32F4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; USE_STM32F4_EVB; STM32F4XX; STM32F401X; AKM_MAGNETOMETER_AK09911; AKSC_VERSION_DEVICE=9911; AKL_SKIP_HW_CHECK; DEBUG; AKM_DISABLE_DOEPLUS; AKM_CUSTOM_CONTINUOUS_MEASURE; __DOEAG_MODE_EN; ACC_SENSOR_DISABLE; AKM_ACCELEROMETER_DUMMY; AKM_ENABLE_PDC
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: ..\..\..\Libraries\STM32_Common; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F4xx_HAL_Driver\inc; ..\..\..\Libraries\CMSIS\Device\STM32F4xx\Include; ..\..\..\..\FreeRTOS\FreeRTOS821\Source\include; ..\..\..\..\FreeRTOS\FreeRTOS821\Source\portable\IAR\ARM_CM4F; ..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\Libraries\STM32_CPAL_Driver\devices\stm32f4xx; ..\..\..\..\System\Algorithm\inc; ..\..\..\..\System\Driver\inc; ..\..\..\..\System\DriverLibrary\AKM8963\inc; ..\..\..\..\System\DriverLibrary\AKM09911\inc; ..\..\..\..\System\DriverLibrary\AKM09911AG\; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_HAL; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library\libag; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library\libSmartCompass; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Sensors; ..\..\..\..\System\DriverLibrary\MMC3524xPJ; ..\..\..\..\System\DriverLibrary\ST480M; ..\..\..\..\System\DriverLibrary\Yamaha\inc; ..\..\..\..\System\DriverLibrary\YamahaMini\inc; ..\..\..\..\System\Manager\inc; ..\..\..\..\System\Utils\inc; ..\..\..\Release\Driver\inc; ..\..\..\Release\Manager\inc; ..\..\..\Release\Platform\inc; ..\..\..\Release\RtosTask\inc; ..\..\..\Release\System\inc; ..\..\..\Release\SystemConfig\inc; ..\..\..\..\..\Source\inc; ..\..\..\; C:\work\Develop\Source\Manager; C:\work\Develop\Source\Common; C:\work\Develop\Source\Platform_Dependent; C:\work\Develop\Source\Android; C:\work\Develop\Source\TimeSync; C:\work\Develop\Source\Protocol
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\Release\Platform\inc; ..\..\..\Release\System\inc
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash_EEPROM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: CWM_DataSorting.c cwm_pick_up_api.c main.c
