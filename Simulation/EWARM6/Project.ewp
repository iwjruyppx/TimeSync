# IAR project Project.ewp, settings and files
configuration STM32F4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401VC ST STM32F401VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; USE_STM32F4_EVB; STM32F4XX; STM32F401X; AKM_MAGNETOMETER_AK09911; AKSC_VERSION_DEVICE=9911; AKL_SKIP_HW_CHECK; DEBUG; AKM_DISABLE_DOEPLUS; AKM_CUSTOM_CONTINUOUS_MEASURE; __DOEAG_MODE_EN; ACC_SENSOR_DISABLE; AKM_ACCELEROMETER_DUMMY; AKM_ENABLE_PDC
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: ..\..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\Release\Platform\inc; ..\..\..\Release\System\inc
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash_EEPROM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
    ../../: TimeSync.c TimeSyncSlop.c
